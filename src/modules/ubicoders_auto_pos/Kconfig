## src/modules/ubicoders_auto_pos/Kconfig
```kconfig
menuconfig MODULES_ubicoders_auto_pos
	bool "ubicoders_auto_pos"
	default y
	---help---
		Enable support for ubicoders_auto_pos
```
